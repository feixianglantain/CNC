# Keil uVision project GRBL_F427.uvprojx, settings and files
target GRBL_F427 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: GRBL_F427
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,STM32
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ..\grbl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group grbl
    ../grbl/: grbl_main.c config.h cpu_map.h defaults.h grbl.h coolant_control.c coolant_control.h eeprom.c eeprom.h gcode.c gcode.h limits.c limits.h motion_control.c motion_control.h nuts_bolts.c nuts_bolts.h planner.c planner.h print.c print.h protocol.h probe.c probe.h protocol.c report.c report.h serial.c serial.h settings.c settings.h spindle_control.c spindle_control.h stepper.c stepper.h system.c system.h jog.c jog.h
  group Application/User
    ../Src/: main.c usart.c stm32f4xx_hal_msp.c gpio.c tim.c stm32f4xx_it.c delay.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c
software components: CMSIS:CORE 4.3.0
